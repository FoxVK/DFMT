# Repository FoxVK/DFMT

File README.md:

# DFMT
USB Dual FM tuner radio based on PIC 32MX250F128B (or 32MX220F032B) and two LW/SW/FM receivers with I2S output SI4735-D60.

First version of device will alows you to receive sound from first tuner while second tuner can by used for seeking other stations, reciving RDS, obtaining signal metrics, etc...  Unlike SW and FW, hardware was desinged to be as usiversal as possible, so on pcb is interconnection of both audio outputs with MCU, simplified ISP connector and there are soldering pads for both FM and SW/MW/LW inputs.

#Goal
 Be able to receive FM radio with RDS informations.
 
#State of art:
##Firmware:
* Inicialization of tuners is done.
* USB core is done and working.
* USB sunspend is not implemented. Lower power consupmtion to USB spec. limit is not possible but is planned to make it low as possible.
* USB testmode is not implemented and porbably never be because is useful only for certificaion purposes.
* USB-I2C tunnel is done and tested.
* USB audio is done and tesed. (only a subset of audio 1.0 specification)
* USB VID and PID: Random ones are currently used but there seems to be no porblem to get one from Microchip.
* I2C is done and tested.
* I2S is working but there is a problem with discarding buffers due to USB and I2S clock inaccuracy.

##Software:

### Library libdfmt:
* low level interface: Done and tested exept ping.
* Middle level interface is done and tested.
* High level interface is under construction. Only tune cmd is available right now

### Gui:
* Has a bit slow responses because of wrong design
* Tunig and seek works.
* Seek other stations by second tuner. Works but cold be better.
* RDS. Not implemented yet.

## Hardware:
* Schematic was sucessfully tested on breadborad.
* First PCB is finally assembled and successfuly tested.

* Issues:
  * Span of holes for buttons is 1mm bigger, but with little bit effort buttons fits.
  * Silkscreen of LE33 and PIC have no orientation mark.
  * Swapped labels PGD and RST.
* Acrylic case could be nice.

## KiCad design hardware/kicad/dfmt.kicad_pcb

Parts:
C1, C7, C9, C12, C15, C16: 100nF; C_1206_HandSoldering
C2, C4: 1nF; C_1206_HandSoldering
C3, C5: 470nF; C_1206_HandSoldering
C6, C8, C10, C11: 22pF; C_1206_HandSoldering
C13, C14: 2.2uF; TantalC_SizeB_EIA-3528_HandSoldering
C17: 10uF; TantalC_SizeB_EIA-3528_HandSoldering
IC1, IC2: SI4735-D60; SSOP-24_3.9x8.7mm_Pitch0.635mm
IC3: LE33-SMT; SO-8
L1: 10uH; R_1210_HandSoldering
MCU1: PIC32MX220F032B; DIP-28_W7.62mm
P1: FM ANT; Pin_Header_Straight_1x02
P2: AM ANT; Pin_Header_Straight_1x02
P3: PROG; Pin_Header_Straight_1x03
P4: USB_OTG; USB_Mini-B
R1, R4: 5R6; R_1206_HandSoldering
R2, R3, R5, R6: 2k2; R_1206_HandSoldering
R7, R8, R9: 4k7; R_1206_HandSoldering
SW1: UP; button-TACT
SW2: DOWN; button-TACT
Y1: 8MHz; Crystal_HC49-SD_SMD

Connections:
/DCLK: MCU1.25 (RB14), MCU1.26 (RB15), R3.2, R6.2
/DFS: MCU1.4 (RB0), MCU1.7 (RB3), P3.2, R2.2, R5.2
/DOUT_A: MCU1.14 (RB5), R1.2
/DOUT_B: MCU1.12 (RA4), R4.2
/RST: IC1.15 (RSTB), IC2.15 (RSTB), MCU1.6 (RB2)
/SCLK: IC1.17 (SCLK), IC2.17 (SCLK), MCU1.17 (RB8), R9.2
/SDA: IC1.18 (SDIO), IC2.18 (SDIO), MCU1.18 (RB9), R8.2
GND: C1.1, C7.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, IC1.9 (RFGND), IC1.10 (NC), IC1.11 (NC), IC1.13 (GND), IC1.14 (GND), IC1.16 (SENB), IC2.9 (RFGND), IC2.10 (NC), IC2.11 (NC), IC2.13 (GND), IC2.14 (GND), IC3.2 (GND), IC3.3 (GND), IC3.5 (INHIBIT), IC3.6 (GND), IC3.7 (GND), MCU1.8 (VSS), MCU1.19 (Vss), MCU1.27 (AVSS), P2.1, P4.4, P4.5, SW1.2, SW2.2
unnamed: C1.2, P1.1
unnamed: C2.1, C4.1, P1.2
unnamed: C2.2, IC1.8 (FMI)
unnamed: C3.1, C5.1, P2.2
unnamed: C3.2, IC1.12 (AMI)
unnamed: C4.2, IC2.8 (FMI)
unnamed: C5.2, IC2.12 (AMI)
unnamed: C6.1, IC1.22 (DBYP)
unnamed: C8.1, IC2.22 (DBYP)
unnamed: C10.1, MCU1.9 (RA2), Y1.1
unnamed: C11.1, MCU1.10 (RA3), Y1.2
unnamed: C13.1, L1.1, P4.1
unnamed: C14.1, C15.1, IC3.8 (Vin), L1.2
unnamed: C17.1, MCU1.20 (VCAP)
unnamed: IC1.1 (DOUT), R1.1
unnamed: IC1.2 (DFS), R2.1
unnamed: IC1.3 (GPO3/DCLK), R3.1
unnamed: IC2.1 (DOUT), R4.1
unnamed: IC2.2 (DFS), R5.1
unnamed: IC2.3 (GPO3/DCLK), R6.1
unnamed: MCU1.1 (MCLR), P3.3, R7.2
unnamed: MCU1.5 (RB1), P3.1
unnamed: MCU1.16 (RB7), SW2.1
unnamed: MCU1.21 (RB10), P4.3
unnamed: MCU1.22 (RB11), P4.2
unnamed: MCU1.24 (RB13), SW1.1
VDD: C6.2, C7.1, C8.2, C9.1, C12.1, C16.1, IC1.20 (VD), IC1.21 (VA), IC2.16 (SENB), IC2.20 (VD), IC2.21 (VA), IC3.1 (VOUT), MCU1.13 (VDD), MCU1.15 (VBUS), MCU1.23 (VUSB3v3), MCU1.28 (AVDD), R7.1, R8.1, R9.1

Board: 2 copper layers, 50.0 x 50.0 mm, 38 parts (19 on the bottom side), 35 nets.

## Commit log

2015-05-14 Created empty MPLAB X project with PIC32MX250F128
2015-05-14 Added uart debug funtion without iterrupts and basic device configuration.
2015-05-14 Added app.c/h.
2015-05-14 Deleted commentd old code
2015-05-14 Added delay after reset.
2015-05-14 Added call of app_task insteda of debug_uart_task
2015-05-14 Truely added app.c and .h and added uint2hex in drv/utils
2015-05-14 Added virt2phy
2015-05-14 Added bool type
2015-05-14 Added some files for USB driver
2015-05-15 Added buffer descriptor table without init
2015-05-19 basic usb seems to be working (tested with minimal configuration)
2015-05-20 added WISZ_25 definition for compatibility with older XC32
2015-05-20 Updated usb.h and added function usb_is_suspended()
2015-05-20 Added transfer and control transfer callback support.
2015-05-20 Added usb_queued_bufs()
2015-05-21 added user datat pointer returned by tansfer callback
2015-05-21 Only one ebug msg change.
2015-05-21 Added verz simple audio driver - working weird
2015-05-21 added get status request, Seems to be working but many other mandatory requests is still missing.
2015-05-21 added & to get status request
2015-05-21 added USB_USED_ENDPOINTS macro to save memory
2015-05-23 created eagle porject with schematic an library without MCU
2015-05-23 upadte .gitignore - added eagle temporary files
2015-05-23 Added MCU into library
2015-05-23 Schematic of MCU was too big
2015-05-23 working version
2015-06-03 added kicad schematic without buttons
2015-06-11 finished schematic with DIP mcu and not common DFS and DCLK
2015-06-17 I2S2 changed to slave mode. Will be driven by first I2S.
2015-06-17 Added debughalt()
2015-06-17 Added tuner functions from older version. Some chnages still needed.
2015-06-17 Added copyright
2015-06-17 removed abandoned drv_uart_debug.h
2015-06-19 Added some exported files of unfinidhed board
2015-06-19 PCB second try. Unfinished
2015-08-24 Added queue.
2015-08-24 Added queue_count()
2015-08-27 Sending data from I2S to USB ready to test. I2S is alwas running Data are trasfered through pairs of chained DMA chnnels
2015-09-08 Sending data from I2S to USB is amlost working. (packet loss) I2S is alwas running Data are trasfered through pairs of chained DMA chnnels
2015-09-10 QTcreator main project "software" created
2015-09-11 Initial commit of libdfmt
2015-09-16 Performed investigation on packet loss. Seems to be in slow DMA. Will be sloved later
2015-09-17 lib dfmt created Problem with includes
2015-09-17 Fixed bad guard symbol in libdfmt.h
2015-09-17 Added i2c over usb tunnel but not tested
2015-09-20 First sucessful test of libdfmt Can only detect device connection and handle openeing and closing
2015-09-21 i2c over usb tunnel seems to be working fixed returning request buffers
2015-09-21 Added Exception catching function with debug_uart output
2015-09-21 Tuners are not responding to i2c
2015-09-23 Added TRIS bits config for I2C
2015-09-24 Before presentation. I2C com and initialization is working. (Malfunction caused by logic analyzer) I2C over USB is probably working on MCU side Libdfmt has problem with sending of datas. Is successfu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
2015-09-25 Fixed audio packet loss. Missing constants in queue inicialization...
2015-09-25 Fixed tunnel Added data01 strobing
2015-09-25 Removed some debugging msgs
2015-10-10 Borad v 1.0 without logo. Verification of USB connector needed ! There are no holes but place on edges.
2015-10-10 Images of board v1.0
2015-10-10 MiniB connector changed to mature B, but is not in the middle of board. Still no logo, no holes.
2015-10-11 Added two holes.
2015-10-14 HW v1.0 sent to fab. USB connector was modified to not go outside of PCB. Actual pictures was made. Updated schematic pdf wit new USB con. Added gerber and excelon files.
2015-10-14 Udev rule created to chmod tuner
2015-10-14 gitignore for software created to supress some QT creator mess.
2015-10-14 New three level layout of libdfmt with doxygen. Tunning is succesfully tested.
2015-10-24 Added basic dimesions on PCB
2015-11-07 libdfmt: added seek get freq + metrics a receiving RDS without parsing All need to be tested.
2015-11-19 Corrected values of some components.
2015-11-22 Fixed disconnecting of tuner, added zero optimizations to makefile.
2015-11-22 Working version of GUI with tabs, window icon and creepy menu bar. Works: seek, tunning, connecting/disconnecting tuners Mutiple tuners should by working too but not tested Not implemented: Sound. Bu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
2015-11-23 deleted old file
2015-11-26 GUI: tunning and seeking works reliable metrics are shown and periodically updated but are mesured by tuner only once after tunnig added screenshot LIB: fixed falgs in seek cmd
2015-11-26 untested working vesrsion / missing interconnection with taskB
2015-12-08 Photos of board and current screenshot of GUI
2015-12-25 Thesis - first commit.
2015-12-25 Thesis - first commit (added forgoten PDF)
2015-12-25 Added draft of english abstract.
2015-12-28 Added bunch of references.
2015-12-28 Splited into chapters
2015-12-28 Chapter seeking parts almost done.
2015-12-29 Added description of TAS and 8Bit pic
2015-12-29 Added pdf with description of TAS and 8Bit pic
2016-01-02 Missing resolution of design
2016-01-02 Libusb win32 version. Untested. + some gui changes
2016-01-02 win32 GUI build (untested)
2016-01-06 Added short USB and USB Audio spec. versions brief. Added some acronyms.
2016-01-09 Block schematic of design.
2016-01-09 Block schematic of design - added AM
2016-01-09 Added LE33 into bibliography
2016-01-09 Finished chapter Parts selection, added dashed arrows to unused connection in block diagram.
2016-01-10 Added figure usb-functions
2016-01-12 usb comm
2016-01-13 Finished USB communication. Started descriptors. Forced positiongin of all figures and tables.
2016-01-16 Added device descriptor, VID price with bib reference
2016-02-09 String descriptors without table.
2016-02-13 Added configuration descriptor and audi introduction + AC descriptors
2016-02-14 compile error
2016-02-14 deletion of forgoten file
2016-02-14 Added audio stremaing descriptors (only tables)
2016-02-20 Only one description of audio descripotr is missing
2016-02-21 Finished Audio descriptors and repositioning of tables
2016-02-27 Swapped chapter Tuner and USB, added more TODOs, added i2s subsection.
2016-03-20 Description of Harmony + some small changes
2016-03-29 Working good with minority disortions
2016-04-02 Added GET_CONFIGURATION request support.
2016-04-02 Added Stadard USB reqs, USB module in MCU
2016-04-11 Added Tuner commands intro and tuner inicialization section.
2016-04-11 Some small changes to FW
2016-04-12 added Tuner intro and i2s module in mcu was joined with usb i2c tunel section
2016-04-13 Corrections and added schematic.
2016-04-16 Finished Tuner chapter
2016-04-16 Tuner chaper finished - 2nd try
2016-04-16 Converted on new version of school template - Diploma 4.0
2016-04-17 Part of introduction chapter.
2016-04-17 Added assignment
2016-04-17 Software converted to Qmmake project
2016-04-22 Working FW with small audi distortions
2016-04-22 Cleaning of Fimrware
2016-04-22 Added Micro$ WCID support to siplify drv instalation on Window$
2016-04-23 Fixed project file
2016-04-23 Added forgoten libusb.h for win.
2016-04-23 modified for windows mingw
2016-04-24 Moved Udev rules
2016-04-24 Zadig modified to install libusbK
2016-04-24 Hope final firmaware 1.0
    Tunerd on basic optimization
    Added workaround of memroy leak to usb i2c tunel
    Added production hex dist/default/production/firmware.production.hex
2016-04-25 Added win drv install screenshots
2016-04-25 Added driver instatlation
2016-04-25 Linux driver
2016-04-25 Added Transfer I2S USB sound transfer + some minor corrections - description of correciton algorihm
2016-04-25 Fixed USB pictures
2016-04-25 Gui without menu
2016-04-25 Added and tested RDS - fixed both functions in libdfmt - Added radiotext to GUI with decoder.
2016-04-26 Changed RT font and modified table behavior
2016-04-26 Added libdfmt as depency of dfmtgui.
2016-04-26 win32 build
2016-04-26 Win cross build - 2nd try.
2016-04-26 Before correction - GUI part is unfinished
2016-04-26 Added SVG to modules and fixed libdfmt name for win compilation
2016-04-26 wn32build with svg support (hope)
2016-04-27 driver moved in to software
2016-04-27 Added BOM and CD structure description
2016-04-28 Final vesion of gui and diploma.
2016-04-28 Added repairing driver to diploma and deleted test.c from libdfmt
2016-04-28 Diploma done B-)
    - Corrected added generated doc to libdfmt
    - Removed debug prints from gui
    - Added signed scans of some pages in diploma
2016-04-28 Removed old project files
